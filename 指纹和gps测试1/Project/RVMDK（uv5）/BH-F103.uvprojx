# Keil uVision project BH-F103.uvprojx, settings and files
target as608 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: as608 +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\usart;..\..\User\as608;..\..\User\led;..\..\User\SysTick;..\..\User\nmea_decode\include;..\..\User\nmea_decode;..\..\User\FATFS\drivers;..\..\User\FATFS;..\..\User\nmea_decode\src;..\..\User\Bsp\key;..\..\User\gps
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h nema_decode_test.c bsp_exti.c ccsbcs.c
    ../../User/usart/: rx_data_queue.c bsp_usart1.c
    ../../User/as608/: as608_test.c bsp_as608.c
    ../../User/led/: bsp_led.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/Key/: bsp_key.c
    ../../User/FATFS/: diskio.c ff.c
    ../../User/nmea_decode/src/: context.c generate.c generator.c gmath.c info.c parse.c parser.c sentence.c time.c tok.c
    ../../User/FATFS/drivers/: fatfs_flash_spi.c fatfs_sd_sdio.c
    ../../User/FATFS/option/: syscall.c
    ../../User/gps/: gps_config.c
  group DOC
    ../../Doc/: readme.txt
